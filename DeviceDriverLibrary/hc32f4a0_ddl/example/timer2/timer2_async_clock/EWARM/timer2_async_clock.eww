<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\timer2_async_clock.ewp</path>
  </project>
  <batchBuild/>
</workspace>


