<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\exmc_dmc_sdram_is42s16400j7tli.ewp</path>
  </project>
  <batchBuild/>
</workspace>


