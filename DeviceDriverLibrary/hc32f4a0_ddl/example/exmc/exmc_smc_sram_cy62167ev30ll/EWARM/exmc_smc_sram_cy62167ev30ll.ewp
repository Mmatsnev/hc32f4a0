# IAR project exmc_smc_sram_cy62167ev30ll.ewp, settings and files
configuration Debug (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG; HC32F4A0; USE_DDL_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\..\mcu\common; ..\source; ..\..\..\..\driver\inc; ..\..\..\..\bsp\ms_hc32f4a0_lqfp176_050_mem; ..\..\..\..\bsp\components\cy62167ev30ll
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: exmc_smc_sram_cy62167ev30ll.srec
  ILINK.IlinkOutputFile: exmc_smc_sram_cy62167ev30ll.out
  ILINK.IlinkIcfFile: hc32f4a0.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: HC32F4A0; USE_DDL_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\..\mcu\common; ..\source; ..\..\..\..\driver\inc; ..\..\..\..\bsp\ms_hc32f4a0_lqfp176_050_mem; ..\..\..\..\bsp\components\cy62167ev30ll; ..\..\..\..\utility
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group (top)
    ../: Readme.txt
  group common
    ../../../../mcu/common/: system_hc32f4a0.c
    ./: startup_hc32f4a0.s
  group driver
    ../../../../driver/src/: hc32f4a0_gpio.c hc32f4a0_pwc.c hc32f4a0_smc.c hc32f4a0_clk.c hc32f4a0_utility.c hc32f4a0_efm.c hc32f4a0_sram.c hc32f4a0_interrupts.c hc32f4a0_icg.c
  group bsp/ms_hc32f4a0_lqfp176_050_mem
    ../../../../bsp/ms_hc32f4a0_lqfp176_050_mem/: ms_hc32f4a0_lqfp176_050_mem.c ms_hc32f4a0_lqfp176_050_mem_cy62167ev30ll.c
  group bsp/cy62167ev30ll
    ../../../../bsp/components/cy62167ev30ll/: cy62167ev30ll.c
  group source
    ../source/: main.c
