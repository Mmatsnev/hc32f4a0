<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\exmc_smc_nor_s29gl064n90tfi03.ewp</path>
  </project>
  <batchBuild/>
</workspace>


