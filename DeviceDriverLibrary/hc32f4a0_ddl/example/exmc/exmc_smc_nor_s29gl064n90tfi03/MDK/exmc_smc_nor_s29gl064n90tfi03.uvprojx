# Keil uVision project exmc_smc_nor_s29gl064n90tfi03.uvprojx, settings and files
target exmc_smc_nor_s29gl064n90tfi03_Debug (5060020::V5.06 (build 20)::ARMCC)
  device: HC32F4A0SITB HDSC
  pack: HDSC.HC32F4A0.1.0.0
  cpu: IROM(0x00000000,0x200000) IRAM(0x1FFE0000,0x80000)  IRAM2(0X200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(240000000) ESEL ELITTLE
  output: exmc_smc_nor_s29gl064n90tfi03
  c flags: oTime=1 OneElfS=1 uC99=1
  c define: __DEBUG,HC32F4A0,USE_DDL_DRIVER
  c misc: --diag_suppress=186,66
  c include: ..\..\..\..\mcu\common;..\source;..\..\..\..\driver\inc;..\..\..\..\bsp\ms_hc32f4a0_lqfp176_050_mem;..\..\..\..\bsp\components\s29gl064n90tfi03;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x1FFE0000 size 0x80000
  memory RVCT10: RAM 0x200F0000 size 0x1000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32f4a0.s
    ../../../../mcu/common/: system_hc32f4a0.c
  group source
    ../source/: main.c
  group driver
    ../../../../driver/src/: hc32f4a0_clk.c hc32f4a0_smc.c hc32f4a0_interrupts.c hc32f4a0_pwc.c hc32f4a0_sram.c hc32f4a0_utility.c hc32f4a0_efm.c hc32f4a0_gpio.c hc32f4a0_icg.c
  group ms_hc32f4a0_lqfp176_050_mem
    ../../../../bsp/ms_hc32f4a0_lqfp176_050_mem/: ms_hc32f4a0_lqfp176_050_mem.c ms_hc32f4a0_lqfp176_050_mem_s29gl064n90tfi03.c
  group s29gl064n90tfi03
    ../../../../bsp/components/s29gl064n90tfi03/: s29gl064n90tfi03.c
  group Readme
    ../: Readme.txt
target exmc_smc_nor_s29gl064n90tfi03_Release (5060020::V5.06 (build 20)::ARMCC)
  device: HC32F4A0SITB HDSC
  pack: HDSC.HC32F4A0.1.0.0
  cpu: IROM(0x00000000,0x200000) IRAM(0x1FFE0000,0x80000) IRAM2(0X200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(240000000) ESEL ELITTLE
  output: exmc_smc_nor_s29gl064n90tfi03 +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1
  c define: HC32F4A0,USE_DDL_DRIVER
  c misc: --diag_suppress=186,66
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x1FFE0000 size 0x80000
  memory RVCT10: RAM 0x200F0000 size 0x1000
  link misc: --keep=*Handler
software components: CMSIS:CORE 5.0.1
