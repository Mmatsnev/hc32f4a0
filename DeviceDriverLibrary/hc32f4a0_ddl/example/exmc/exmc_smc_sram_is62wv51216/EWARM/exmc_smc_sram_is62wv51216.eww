<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\exmc_smc_sram_is62wv51216.ewp</path>
  </project>
  <batchBuild/>
</workspace>


