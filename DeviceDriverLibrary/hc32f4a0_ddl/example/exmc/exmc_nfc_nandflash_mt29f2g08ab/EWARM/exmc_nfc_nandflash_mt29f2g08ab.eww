<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\exmc_nfc_nandflash_mt29f2g08ab.ewp</path>
  </project>
  <batchBuild/>
</workspace>


