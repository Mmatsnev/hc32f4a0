# Keil uVision project exmc_nfc_nandflash_mt29f2g08ab.uvprojx, settings and files
target exmc_nfc_nandflash_mt29f2g08ab_Debug (5060020::V5.06 (build 20)::ARMCC)
  device: HC32F4A0SITB HDSC
  pack: HDSC.HC32F4A0.1.0.0
  cpu: IROM(0x00000000,0x200000) IRAM(0x1FFE0000,0x80000)  IRAM2(0X200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(240000000) ESEL ELITTLE
  output: exmc_nfc_nandflash_mt29f2g08ab
  c flags: oTime=1 OneElfS=1 uC99=1
  c define: __DEBUG,HC32F4A0,USE_DDL_DRIVER
  c misc: --diag_suppress=186,66
  c include: ..\..\..\..\mcu\common;..\source;..\..\..\..\driver\inc;..\..\..\..\bsp\ev_hc32f4a0_lqfp176;..\..\..\..\bsp\components\mt29f2g08ab;..\..\..\..\bsp\components\tca9539;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x1FFE0000 size 0x80000
  memory RVCT10: RAM 0x200F0000 size 0x1000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32f4a0.s
    ../../../../mcu/common/: system_hc32f4a0.c
  group source
    ../source/: main.c
  group driver
    ../../../../driver/src/: hc32f4a0_clk.c hc32f4a0_nfc.c hc32f4a0_interrupts.c hc32f4a0_pwc.c hc32f4a0_sram.c hc32f4a0_utility.c hc32f4a0_efm.c hc32f4a0_gpio.c hc32f4a0_icg.c hc32f4a0_i2c.c hc32f4a0_keyscan.c
  group ev_hc32f4a0_lqfp176
    ../../../../bsp/ev_hc32f4a0_lqfp176/: ev_hc32f4a0_lqfp176.c ev_hc32f4a0_lqfp176_mt29f2g08ab.c ev_hc32f4a0_lqfp176_tca9539.c
  group mt29f2g08ab
    ../../../../bsp/components/mt29f2g08ab/: mt29f2g08ab.c
  group tca9539
    ../../../../bsp/components/tca9539/: tca9539.c
  group Readme
    ../: Readme.txt
target exmc_nfc_nandflash_mt29f2g08ab_Release (5060020::V5.06 (build 20)::ARMCC)
  device: HC32F4A0SITB HDSC
  pack: HDSC.HC32F4A0.1.0.0
  cpu: IROM(0x00000000,0x200000) IRAM(0x1FFE0000,0x80000) IRAM2(0X200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(240000000) ESEL ELITTLE
  output: exmc_nfc_nandflash_mt29f2g08ab +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1
  c define: HC32F4A0,USE_DDL_DRIVER
  c misc: --diag_suppress=186,66
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x1FFE0000 size 0x80000
  memory RVCT10: RAM 0x200F0000 size 0x1000
  link misc: --keep=*Handler
  group added to the first target's files
    ../../../../example/exmc/exmc_nfc_nandflash_mt29f2g08ab/source/: 1bit_per_512byte_ecc.c a_to_i.c decode_4bit_ecc_err_loc.c i_to_a.c
software components: CMSIS:CORE 5.0.1
