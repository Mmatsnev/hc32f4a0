# Keil uVision project usbd_hid_msc.uvprojx, settings and files
target usbd_hid_msc_Debug (5060020::V5.06 (build 20)::ARMCC)
  device: HC32F4A0SITB HDSC
  pack: HDSC.HC32F4A0.1.0.0
  cpu: IROM(0x00000000,0x200000) IRAM(0x1FFE0000,0x80000)  IRAM2(0X200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(240000000) ESEL ELITTLE
  output: usbd_hid_msc
  c flags: oTime=1 OneElfS=1 uC99=1
  c define: __DEBUG,HC32F4A0,USE_DDL_DRIVER
  c misc: --diag_suppress=186,66
  c include: ..\..\..\..\mcu\common;..\source;..\..\..\..\driver\inc;..\..\..\..\bsp\ev_hc32f4a0_lqfp176;..\..\..\..\bsp\components\tca9539;..\..\..\..\bsp\components\w25qxx;..\..\..\..\midware\usb_device_lib\device_core;..\..\..\..\midware\usb_device_lib\device_class\hid_custom;..\..\..\..\midware\usb_device_lib\device_class\hid_msc_wrapper;..\..\..\..\midware\usb_device_lib\device_class\msc;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x1FFE0000 size 0x80000
  memory RVCT10: RAM 0x200F0000 size 0x1000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32f4a0.s
    ../../../../mcu/common/: system_hc32f4a0.c
  group source
    ../source/: main.c
  group driver
    ../../../../driver/src/: hc32f4a0_gpio.c hc32f4a0_pwc.c hc32f4a0_i2c.c hc32f4a0_clk.c hc32f4a0_utility.c hc32f4a0_usart.c hc32f4a0_efm.c hc32f4a0_sram.c hc32f4a0_spi.c hc32f4a0_interrupts.c hc32f4a0_icg.c hc32f4a0_keyscan.c hc32f4a0_usb_core.c hc32f4a0_usb_otg.c hc32f4a0_usb_dcd.c hc32f4a0_usb_dcd_int.c
  group usb_device_lib
    ../../../../midware/usb_device_lib/device_core/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../../../../midware/usb_device_lib/device_class/hid_custom/: usbd_hid_custom_core.c
    ../../../../midware/usb_device_lib/device_class/hid_msc_wrapper/: usbd_hid_msc_wrapper.c
    ../../../../midware/usb_device_lib/device_class/msc/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group ev_hc32f4a0_lqfp176
    ../../../../bsp/ev_hc32f4a0_lqfp176/: ev_hc32f4a0_lqfp176.c ev_hc32f4a0_lqfp176_tca9539.c ev_hc32f4a0_lqfp176_w25qxx.c
  group tca9539
    ../../../../bsp/components/tca9539/: tca9539.c
  group w25qxx
    ../../../../bsp/components/w25qxx/: w25qxx.c
  group Readme
    ../: Readme.txt
target usbd_hid_msc_Release (5060020::V5.06 (build 20)::ARMCC)
  device: HC32F4A0SITB HDSC
  pack: HDSC.HC32F4A0.1.0.0
  cpu: IROM(0x00000000,0x200000) IRAM(0x1FFE0000,0x80000) IRAM2(0X200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(240000000) ESEL ELITTLE
  output: usbd_hid_msc +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1
  c define: HC32F4A0,USE_DDL_DRIVER
  c misc: --diag_suppress=186,66
  c include: ..\..\..\..\mcu\common;..\source;..\..\..\..\driver\inc;..\..\..\..\midware\usb_device_lib\device_core;..\..\..\..\midware\usb_device_lib\device_class\hid_custom;..\..\..\..\midware\usb_device_lib\device_class\hid_msc_wrapper;..\..\..\..\midware\usb_device_lib\device_class\msc;..\..\..\..\bsp\ev_hc32f4a0_lqfp176;..\..\..\..\bsp\components\tca9539;..\..\..\..\bsp\components\w25qxx;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x1FFE0000 size 0x80000
  memory RVCT10: RAM 0x200F0000 size 0x1000
  link misc: --keep=*Handler
  group added to the first target's files
    ../../../../example/usb/usbd_hid_msc/source/: usb_bsp.c usbd_desc.c usbd_storage_msd.c usbd_usr.c
software components: CMSIS:CORE 5.0.1
