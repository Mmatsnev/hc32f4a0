# IAR project usbh_mouse_kb.ewp, settings and files
configuration Debug (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG; HC32F4A0; USE_DDL_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\..\mcu\common; ..\source; ..\..\..\..\driver\inc; ..\..\..\..\midware\usb_host_lib\host_core; ..\..\..\..\midware\usb_host_lib\host_class\hid; ..\..\..\..\bsp\ev_hc32f4a0_lqfp176; ..\..\..\..\bsp\components\tca9539
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: usbh_mouse_kb.srec
  ILINK.IlinkOutputFile: usbh_mouse_kb.out
  ILINK.IlinkIcfFile: hc32f4a0.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: HC32F4A0; USE_DDL_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\..\mcu\common; ..\source; ..\..\..\..\driver\inc; ..\..\..\..\midware\usb_host_lib\host_core; ..\..\..\..\midware\usb_host_lib\host_class\hid; ..\..\..\..\bsp\ev_hc32f4a0_lqfp176; ..\..\..\..\bsp\components\tca9539; ..\..\..\..\utility
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group (top)
    ../: Readme.txt
  group common
    ../../../../mcu/common/: system_hc32f4a0.c
    ./: startup_hc32f4a0.s
  group driver
    ../../../../driver/src/: hc32f4a0_gpio.c hc32f4a0_pwc.c hc32f4a0_i2c.c hc32f4a0_clk.c hc32f4a0_utility.c hc32f4a0_usart.c hc32f4a0_efm.c hc32f4a0_sram.c hc32f4a0_interrupts.c hc32f4a0_icg.c hc32f4a0_keyscan.c hc32f4a0_usb_core.c hc32f4a0_usb_otg.c hc32f4a0_usb_hcd.c hc32f4a0_usb_hcd_int.c
  group midware/usb_host_lib/host_core
    ../../../../midware/usb_host_lib/host_core/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
  group midware/usb_host_lib/host_class/hid
    ../../../../midware/usb_host_lib/host_class/hid/: usbh_hid_core.c usbh_hid_keybd.c usbh_hid_mouse.c
  group bsp/ev_hc32f4a0_lqfp176
    ../../../../bsp/ev_hc32f4a0_lqfp176/: ev_hc32f4a0_lqfp176.c ev_hc32f4a0_lqfp176_tca9539.c
  group bsp/tca9539
    ../../../../bsp/components/tca9539/: tca9539.c
  group source
    ../source/: main.c
    ../../../../example/usb/usbh_mouse_kb/source/: usbh_usr.c usbh_usr_print.c usb_bsp.c
