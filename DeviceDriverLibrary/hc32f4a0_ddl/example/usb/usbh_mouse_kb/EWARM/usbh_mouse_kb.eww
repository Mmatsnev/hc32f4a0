<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\usbh_mouse_kb.ewp</path>
  </project>
  <batchBuild/>
</workspace>


