<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\timera_oc_revolution_count.ewp</path>
  </project>
  <batchBuild/>
</workspace>


